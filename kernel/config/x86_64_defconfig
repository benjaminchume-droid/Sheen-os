## kernel/config/x86_64_defconfig
```kconfig
CONFIG_64BIT=y
CONFIG_X86_64=y
CONFIG_EFI=y
CONFIG_DRM=y
CONFIG_SOUND=y
CONFIG_USB=y
CONFIG_NETWORKING=y
CONFIG_INET=y
```
